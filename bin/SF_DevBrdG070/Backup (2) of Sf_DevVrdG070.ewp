# IAR project Backup (2) of Sf_DevVrdG070.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070CB ST STM32G070CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\source\pub; ..\..\source\interface\media\include; ..\..\source\interface\math\include; ..\..\source\interface\control\include; ..\..\source\interface\communication\common\include; ..\..\source\interface\communication\Knx_protocol_0705_2K_BitChip_Lib\include; ..\..\source\interface\common_driver\include; ..\..\source\drivers\AD\STM32G0XXX\include; ..\..\source\drivers\flash\STM32G0XXX\include; ..\..\source\drivers\knx_bit_chip\st_knx\STM32F_T1T3\include; ..\..\source\drivers\systick\Stm32g0XX\include; ..\..\source\application\demo_application\include; ..\..\source\cpus\STM32G0XXX\include; ..\..\source\products\Sf_DevBrd_G07x\include; ..\..\source\drivers\uart\STM32G0XXX\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sf_DevVrdG070.hex
  ILINK.IlinkOutputFile: Sf_DevVrdG070.out
  ILINK.IlinkIcfFile: D:\KNX\KNX_Demo\CO2Sensor\STKNX_CO2Sensor\source\products\Sf_DevBrd_G07x\source\Cpu_resource_cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../source/application/demo_application/source/: demo_app.c
  group cpu
    ../../source/cpus/STM32G0XXX/source/: startup_stm32g0xx.s stm32g0xx_iwdg.c system_stm32g0xx.c
  group driver
    ../../source/drivers/flash/STM32G0XXX/source/: Stm32G0XX_Flash.c
    ../../source/drivers/uart/STM32G0XXX/source/: stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_usart.c
    ../../source/drivers/systick/Stm32g0XX/source/: Stm32g0xx_systick.c
    ../../source/drivers/AD/STM32G0XXX/source/: Stm32G0xxx_adc.c
  group interface
    ../../source/interface/common_driver/source/: buffer.c common_driver.c mem_malloc.c
    ../../source/interface/communication/common/source/: comm_service.c
    ../../source/interface/media/source/: common_media.c
    ../../source/interface/control/source/: ctrl_service.c
    ../../source/interface/math/source/: math_service.c
  group product
    ../../source/products/Sf_DevBrd_G07x/source/: Application.c Application_Data.c boardctrl.c co2_sensor.c Knx_InternalData.c Knx_Mem.c Main.c serialProc.c stm32g0xx_vector.c
  group protocol
    ../../source/interface/communication/Knx_protocol_0705_2K_BitChip_Lib/source/: App_Api.c Knx_Run.c KnxProp_0705.c
    ../../lib/: stm32g070cbt6_st_lib_Rx_Pa9_CoTmLimit 20220409 Iar 8.40.2 V 1.04.a
